# Keil uVision project bootloader.uvproj, settings and files
target nrf51822_xxaa_s110 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: bootloader +hex
  c flags: Optim=1 wLevel=2
  c define: NRF51,DEBUG_NRF_USER,BOARD_NRF6310,
  c misc: --c99
  c include: ..;..\..\..\..\..\Include;..\..\..\..\..\Include\app_common;..\..\..\..\..\Include\ble;..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\Include\ble\softdevice;..\..\include\app_common
  memory RVCT4: ROM 0x38000 size 0x7000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group Startup Code
    ./../../../../../Source/templates/: system_nrf51.c
    ./: arm_bootloader_startup_nrf51.s
  group Source Code
    ./../: main.c
  group Libraries
    ../../../../../Source/nrf_nvmc/: nrf_nvmc.c
    ../../../../../Source/app_common/: app_fifo.c app_uart.c app_timer.c app_scheduler.c app_gpiote.c app_button.c
    ../../source/app_common/: app_transport_uart.c rpc_transport.c
